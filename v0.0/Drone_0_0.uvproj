# Keil uVision project Drone_0_0.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Drone_0_0
  group drivers
    ./drivers/adc/: adc.c
    ./drivers/clock/: clock.c
    ./drivers/gpio/: gpio.c
    ./drivers/pwm/: pwm.c
    ./drivers/i2c/: i2c.c
    ./drivers/timer/: timer234.c
  group sources
    ./sources/: main.c
  group boot
    ../stm32lib/stm32f10x/boot/stm32f103/: startup-gcc.S
  group services
    ./drivers/services/: motor.c sensors.c functions.c stabilization.c
